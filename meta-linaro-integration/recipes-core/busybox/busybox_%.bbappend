FILESEXTRAPATHS:prepend := "${THISDIR}/files:"

SRC_URI += "file://linaro.cfg \
           "
