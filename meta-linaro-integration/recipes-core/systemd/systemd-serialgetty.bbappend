PR = "r5.1"
FILESEXTRAPATHS:prepend := "${THISDIR}/${BPN}:"
