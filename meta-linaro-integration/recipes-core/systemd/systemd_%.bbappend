PACKAGECONFIG:append = " resolved networkd gcrypt"
